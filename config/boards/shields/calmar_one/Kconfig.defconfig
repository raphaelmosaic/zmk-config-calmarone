## config/boards/shields/calmar_one/Kconfig.defconfig
```kconfig
if SHIELD_calmar_one
            
config ZMK_KEYBOARD_NAME
    default "calmar_one"

endif
```
